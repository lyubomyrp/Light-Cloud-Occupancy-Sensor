# IAR project Backup (4) of emeter-metrology-i2041.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430I2041 MSP430I2041
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: __MSP430__
  ICC430.newCCIncludePaths: ../../emeter-toolkit/include; ../include; $PROJ_DIR$
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430I2041.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../include/: emeter-metrology.h
    ../../emeter-toolkit/emeter-toolkit-i2041/Debug/Exe/: emeter-toolkit-i2041.r43
    ../src/: metrology-background.c metrology-fir-table.c metrology-flash.c metrology-foreground.c metrology-readings.c metrology-setup.c
    ./: metrology-template.h
